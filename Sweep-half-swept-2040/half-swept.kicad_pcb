# Repository johnskiller/Sweep

## KiCad design Sweep-half-swept-2040/half-swept.kicad_pcb

File Sweep-half-swept-2040/README.md:

# Sweep Half Swept

Half of a Sweep2 with a reversible micro-controller footprint.

Parts:
J1: tokas_bp_AudioJack4dpb; TRRS-PJ-313B
J2: OLED; PinHeader_1x04_P2.54mm_Vertical
JP1: Jumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
JP2: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10: Jumper
ROT1, ROT2: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
RSW1: SW_Push; ResetSW
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW20, SW21: SW_Push; Kailh_socket_PG1350_optional_reversible
U1: PICO_RP2040; pi pico jumpper-no dbg

Connections:
A: ROT1.A, ROT2.A, U1.17 (GPIO13)
B: ROT1.B, ROT2.B, U1.19 (GPIO14)
GPIO9: JP2.1 (A), U1.12 (GPIO9)
GPIO17: JP1.2 (C), U1.22 (GPIO17)
unnamed: J2.1, JP6.2, JP10.2
unnamed: J2.2, JP5.2, JP9.2
unnamed: J2.3, JP4.2, JP8.2
unnamed: J2.4, JP3.2, JP7.2
PSwitch1: JP1.1 (A), JP2.2 (B), ROT1.S1, ROT2.S1
SCL: JP5.1, JP8.1, U1.15 (GPIO11)
SDA: JP6.1, JP7.1, SW1.1, U1.14 (GPIO10)
Split: J1.S (B), U1.21 (GPIO16)
Split2: J1.T (A), JP1.3 (B)
Switch1: SW2.1, U1.6 (GPIO4)
Switch2: SW3.1, U1.5 (GPIO3)
Switch3: SW4.1, U1.1 (GPIO0)
Switch4: SW5.1, U1.2 (GPIO1)
Switch5: SW6.1, U1.4 (GPIO2)
Switch6: SW8.1, U1.7 (GPIO5)
Switch7: SW9.1, U1.34 (GPIO28_ADC2)
Switch8: SW10.1, U1.10 (GPIO7)
Switch9: SW11.1, U1.9 (GPIO6)
Switch10: SW12.1, U1.32 (GPIO27_ADC1)
Switch11: SW14.1, U1.31 (GPIO26_ADC0)
Switch12: SW15.1, U1.29 (GPIO22)
Switch13: SW16.1, U1.27 (GPIO21)
Switch14: SW17.1, U1.26 (GPIO20)
Switch15: SW18.1, U1.25 (GPIO19)
Switch16: SW20.1, U1.24 (GPIO18)
Switch17: SW21.1, U1.20 (GPIO15)
Switch19: SW7.1, U1.11 (GPIO8)
Switch20: SW13.1, U1.16 (GPIO12)
gnd: J1.R2 (C), JP3.1, JP10.1, ROT1.C, ROT1.S2, ROT2.C, ROT2.S2, RSW1.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW20.2, SW21.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND)
reset: RSW1.2, U1.30 (RUN)
vcc: JP4.1, JP9.1, U1.36 (3V3)
vsys: J1.R1 (D), U1.39 (VSYS)

Notes on the sheet:
Reset
Useless TRRS
左侧没有LCD的，可以有三个额外按键， 分别是SW1，SW7，SW13 右侧如果采用oled，可以用sw1和sw7gpio pin作为i2c的sda和scl

Board: 2 copper layers, 136.0 x 87.7 mm, 37 parts (5 on the bottom side), 35 nets.

Other parts of the board:
Ref**: Val**; starwars_imp
Ref**#2: Val**; star-wars-mid2

## KiCad design Sweep-half-swept-2040/half-swept copy.kicad_pcb

Board: 2 copper layers, 115.6 x 86.7 mm, 25 parts (0 on the bottom side), 24 nets.

Parts:
J2: AudioJack4dpb; TRRS-PJ-DPB2
R1, R2, R3: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RSW1: SW_Push; ResetSW
SW1, SW7: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21: SW_Push; Kailh_socket_PG1350_optional_reversible
U1: PICO_RP2040; RPi_Pico_TH

Connections:
A: R1.1, SW1.A, SW7.A, U1.26 (GPIO20)
B: R2.1, SW1.B, SW7.B, U1.25 (GPIO19)
Switch1: SW2.1, U1.9 (GPIO6)
Switch2: SW3.1, U1.29 (GPIO22)
Switch3: SW4.1, U1.21 (GPIO16)
Switch4: SW5.1, U1.17 (GPIO13)
Switch5: SW6.1, U1.34 (GPIO28_ADC2)
Switch6: SW8.1, U1.19 (GPIO14)
Switch7: SW9.1, U1.24 (GPIO18)
Switch8: SW10.1, U1.27 (GPIO21)
Switch9: SW11.1, U1.20 (GPIO15)
Switch10: SW12.1, U1.1 (GPIO0)
Switch11: SW14.1, U1.5 (GPIO3)
Switch12: SW15.1, U1.6 (GPIO4)
Switch13: SW16.1, U1.7 (GPIO5)
Switch14: SW17.1, U1.4 (GPIO2)
Switch15: SW18.1, U1.10 (GPIO7)
Switch16: SW20.1, U1.31 (GPIO26_ADC0)
Switch17: SW21.1, U1.32 (GPIO27_ADC1)
Switch18: J2.R1, U1.2 (GPIO1)
Switch19: R3.1, SW1.S1, SW7.S1, U1.22 (GPIO17)
gnd: J2.S, J2.T, R1.2, R2.2, R3.2, RSW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW20.2, SW21.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND)
reset: RSW1.2, U1.30 (RUN)
vcc: J2.R2, SW1.C, SW1.S2, SW7.C, SW7.S2, U1.36 (3V3)

## Commit log

2022-04-13 my sweep2040
